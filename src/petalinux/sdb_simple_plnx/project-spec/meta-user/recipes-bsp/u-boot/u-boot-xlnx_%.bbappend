FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://platform-top.h \
            file://user_2018-06-25-02-11-00.cfg \
            file://user_2018-06-25-02-29-00.cfg \
            "
