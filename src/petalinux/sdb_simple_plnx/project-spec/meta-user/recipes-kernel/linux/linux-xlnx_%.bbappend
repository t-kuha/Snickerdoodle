SRC_URI += "file://user_2018-06-25-02-07-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

