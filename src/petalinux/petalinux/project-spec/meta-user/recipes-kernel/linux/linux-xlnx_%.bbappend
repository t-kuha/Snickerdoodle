SRC_URI += "file://user_2018-03-22-05-10-00.cfg \
            file://user_2018-06-03-10-53-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

